Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-03-19T12:04:57
Author: Mayow, Feodor
Organization: WSP Europe
Made in: ASIFC - 2.11.0.854

# IfcSite
RefElevation: 0 mm

# IfcProxy (4)
ProxyType: PRODUCT
Name
L7.003
L7.002
L7.001
L7
